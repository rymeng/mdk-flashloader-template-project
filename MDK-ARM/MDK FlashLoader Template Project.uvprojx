# Keil uVision project MDK FlashLoader Template Project.uvprojx, settings and files
target MDK FlashLoader (6240000::V6.24::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CHIPNAME_OCFLASH
  AfterMake: cmd.exe /C copy "..\Build\Objects\%L" "..\Build\FLM\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\Application\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Scatter Loading File\flashloader.sct
  link misc: --diag_suppress L6305
  group Application
    ../Application/Source/: FlashDev.c FlashProg.c
